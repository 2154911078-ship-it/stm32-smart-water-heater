# Keil uVision project heat_c6.uvprojx, settings and files
target heat_c6 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x2800) IROM(0x8000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: heat_c6 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\User;.\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group User
    ./User/: main.c bsp.c delay.c lcd1602.c ds18b20.c control.c
  group CMSIS
    ./CMSIS/: startup_stm32f103c6_keil.s system_stm32f103.c
